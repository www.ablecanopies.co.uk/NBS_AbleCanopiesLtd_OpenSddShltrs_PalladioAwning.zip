Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-04-30T15:25:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Apr 30 15:25:27 2020* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{E0006786-4798-4E7E-8F70-6FADE9D7C11B}\ifc* Database version: 5507* Database creation date: Thu Apr 30 15:25:25 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Apr 30 15:25:25 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Apr 30 15:25:25 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: PalladioAwning, NBS_AbleCanopiesLtd_OpenSddShltrs_PalladioAwning:PalladioAwning:191450
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_20_65_78_58 (Uniclass2015)
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AbleCanopiesLtd_OpenSidedShelters_PalladioAwning; ManufacturerName: Able Canopies Ltd; ManufacturerURL: www.ablecanopies.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/gdqzvlio; NBSDescription: Open sided shelters; NBSReference: 45-05-75/315; ProductInformation: www.ablecanopies.co.uk/awnings/full-cassette-awnings/palladio-awning.html; Revision: n/a; Uniclass2015Title: Open sided shelters; Uniclass2015Code: Pr_20_65_78_58; Uniclass2015Version: Products v1.17; Version: 1
Type - NBS_Data - FrameMaterial: Aluminium; FrameFinish: Powder Coated; FrameColour: Powder coated in RAL 9010, RAL 1015, RAL 8014, RAL 9006, RAL 71319; RoofCovering: Acrylic Fabric; OpeningsDoors: n/a; OpeningsWindows: n/a; OpeningsRoofVents: n/a; IntegralServices: n/a; RainwaterDrainage: n/a; Accessories: Benches, Picnic Tables, Wall Play Panels; MaximumWidth: 5500 mm; MaximumProjection: 3600 mm; RollerTube: 70 mm diameter; Framework: Strengthened cassette style awning; Arms - Folding arms aluminium; Arms have springs with plate Flyer's chains; TiltAngle: 5˚ - 50˚; AutomaticDrive: Electronic operation with remote control or manual with hand crank
Type - Pset_FurnitureTypeCommon - Description: Commercial retractable awning is suited to the rigors of any commercial setting including schools, nurseries, retail, restaurants and pubs; MainColor: n/a; NominalDepth: 0 mm; NominalHeight: 0 mm; Style: Awning
Type - IFC - IfcExportAs: IfcBuildingElementProxyType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Open sided shelters; Pr_20_65_78_58; CodePerformance: n/a; Color: www.ablecanopies.co.uk/awning-fabric-colour-options.html; Constituents: n/a; DurationUnit: year; ExpectedLife: 10 year; Features: Retractable, create temporary sun shelter within your outside area; Finish: n/a; Grade: n/a; Manufacturer: sales@ablecanopies.co.uk; Material: n/a; ModelNumber: n/a; ModelReference: Palladio Awning; Name: OpenSidedShelters_PalladioAwning_AbleCanopiesLtd; NominalWidth: 7000 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: 2 year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
